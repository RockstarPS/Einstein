<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00044.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="F8CF02AA-7CE8-48EF-B4CB-2B024129BA7C">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="9A52B343-E054-4865-BD1E-3BFFF703D5C2">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0A708A24-AA92-43E7-9AA9-97224361E640">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="40924BB0-1B4B-4E7E-BC98-329829995B66">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="318FFEAE-B4FA-4494-A7D0-4969995D5A35">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="f0c4b6f5-21d2-4bdb-8a79-ccff0f3a2bb7">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="4670aa9e-92ad-4c02-96a5-f572fed609f8">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0402b54e-cf25-4990-a1ea-1c3964b032b3">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="7701a925-521f-415e-adf5-8e7690f3bee4">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="def87a7b-75b7-4877-b446-8a95efec6d5d">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="eef417fe-b480-4021-a7e4-4969e687b266">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F717F5B2-92CC-42DD-A01C-84C8243EF95F">
          <SHORT-NAME>ComM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="36D8435D-A59D-46EE-805C-C2F17EAC99DC">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="4871F652-4147-408E-861A-0ABCF39A0854">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D54EE3D1-8928-4075-B5E3-ECC2D2DCF644">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="7F9019D5-B94F-4A34-9E93-820E928AB222">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="47B5B23B-4048-44AA-BF63-FF384982BFA9">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="726EF230-ACAB-4C12-B33E-4934AF855BD6">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="7255B12A-CDF6-4BB7-99D1-C72ED1ED642E">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="3F6C1327-20D7-4F2C-ACC4-EA71939066C1">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C108C9C7-6EEF-4145-86FB-0B917FE4DE77">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="404A3ADE-BBBF-4BE4-848C-FB759C87DB0F">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="66FA8495-0625-4C83-9FC6-DF0BC58D7F8C">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0FC5A5FC-AB89-4C29-BF26-E37DD6EE49A5">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="F50DA05D-154A-465B-94EF-307FA60C09A6">
          <SHORT-NAME>ECU</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CF93CC70-9B58-4180-BB7B-29A7B5506D9F">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ABA6D74A-7257-4124-BC1B-70DD92AFB2AC">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E909D7DC-74FB-467F-AFD4-6C831DDBE0E4">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3CE93A1D-0D8A-4F3C-BDD7-08286104DF8F">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="85315CDE-36FA-4A67-BE79-9DB6FAFD03EB">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="40F7296E-4865-4DD8-8953-14F97A1E672B">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D4F67F48-39B0-40B8-80FC-0DD3FF867D91">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B50E06CC-6DA8-4F88-8B9A-6EDEE328909F">
      <SHORT-NAME>E40_Platform_System_SystemPackage</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="81A911F1-0EB2-498E-B410-C8D02EB0AE58">
          <SHORT-NAME>Components</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E2C144AE-9044-4E43-B45F-9A48FE97A991">
          <SHORT-NAME>Types</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="C1521031-2A3F-4739-8746-703003170D8D">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="89456625-40BA-4B1A-BC13-480AED3E45EB">
          <SHORT-NAME>AUTOSAR</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="89346032-625F-4872-90B0-51F715F273EC">
              <SHORT-NAME>DataTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E90B0529-A5E5-4D9D-98D5-1AF5B9806F50">
          <SHORT-NAME>Compositions</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="a49354bf-bc9e-4cb4-bec9-10dbf6951ff9">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4BC26BAA-2160-478B-ADA3-444452EAD7BD">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BD8D8A6C-D4DF-4BC6-B3C2-23DB1005BC8A">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3f1f60c8-fa80-420b-98c9-c3d072a99897">
      <SHORT-NAME>ZARXML_CMP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2253F09A-5EA8-4111-8EE9-127B68C62C04">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="66C5EDEC-7D9C-4885-A366-04659F03F568">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9E5BF4AA-AF91-4281-8285-AB43FA3C287F">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C441858B-A850-4412-B2A6-3E5F87793D05">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D3A92AC1-C39C-4A88-80AC-0B0230B95AFE">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="17c50c7b-9ee5-414a-8dab-cfdc5eda20d9">
      <SHORT-NAME>ZARXML_BASE_TYPES</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2937cd05-0c8c-413a-992e-d67514c2e169">
      <SHORT-NAME>ZARXML_DATA_TYPES</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="c9795de5-395a-4257-ad05-af99b46fe277">
      <SHORT-NAME>ARRoot</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="75a06a85-f098-4283-9308-cc18c2cfcfa5">
          <SHORT-NAME>Types</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1baa29cd-dce8-43df-a068-8ce54b3d4dfe">
          <SHORT-NAME>If</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="80F80C36-772E-4826-8D68-1217F0AFC6CE">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="6682A6A1-1062-4BB0-9943-A060CF76E9AF">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E0DB22F2-FAA1-4F0A-BF41-00547B0F51DA">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="18C3F9A4-8067-4FAA-A6F1-C02B5A5ECF23">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9A69BDB8-4B9F-4F21-B3D5-876E945B19C5">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D2582144-0F0E-4335-8874-94AA5B5BB032">
      <SHORT-NAME>AUTOSAR_Std</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E9D73BB1-E6C2-4A20-B0E9-2042B6AA46DF">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="80A6C7C5-3F0A-4DE3-815F-E3517E97EDAB">
      <SHORT-NAME>Vw_Fpk_System_SystemPackage</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="007B93D0-AAB9-460F-8B9F-52F26F58898C">
          <SHORT-NAME>AUTOSAR</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="B9F95224-DF93-4AA6-BF9E-E24947C3D6CC">
              <SHORT-NAME>DataTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2464C2D7-DA63-47F6-9BEB-8958F2B74829">
          <SHORT-NAME>Types</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="5F06DC37-92EB-43A1-872F-370DEDC1D0F2">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DD3728B5-F332-488F-881E-23477D2B017A">
      <SHORT-NAME>AUTOSAR_SfdA</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="6F4CD81F-D8AB-478C-BC27-A85B2B7020A5">
          <SHORT-NAME>SfdA</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="FB724360-5514-4F85-9882-BDD250D6E702">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="DD2AB90F-0948-41B7-B090-6F838DCB911B">
              <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="D0EC4A6C-7FD5-48D7-8053-331118D64153">
              <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="5421833E-2486-4808-990B-9B417EB83135">
              <SHORT-NAME>PortInterfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0514A18E-9D27-4584-8948-2E73550F872D">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="41779252-3786-4423-8620-D5811A677BB2">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8AF06270-D414-487B-AD40-35C766F468EF">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="56EC8504-FB6F-4FB3-9A65-BBA08606C29F">
          <SHORT-NAME>Unit</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6CDA412D-8C5C-4F45-88F0-51F3CFABB3D9">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1AD82EBE-87C1-4832-A38C-061C3893C46C">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E1DB9DA4-892D-4877-BE05-87ECF28D80E0">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A29C698-EF04-4CF0-839B-E364C6C7D598">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EE5284AA-FC63-4ABA-B02D-1E49B8A51DA5">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="87A1E3C5-8F78-4F74-940D-039417D6054D">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="352BA1BE-08EF-40FF-8674-2BC52B9C1BED">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="26499144-AAA9-4258-BBDE-2390B640FF8F">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EBFAE8A3-D462-4859-8C0E-A2BF1B89B7D2">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C0CDDA37-5674-4D84-BCC7-569FD0A479E8">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="98EC805C-7FCB-41A8-8821-BF6159894AD8">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="c3efa14d-1ab1-46bf-99ce-27c7d219d3cc">
      <SHORT-NAME>ZARXML_PORT_IF</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6AB17DC1-1C9F-4C34-BB08-8A69D26AF92F">
      <SHORT-NAME>AUTOSAR_EcuM</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C0CA9C6C-A00D-43E8-8FA4-284E3FE2221F">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6EEF84CF-08D2-4B71-B864-80BDA23DBE42">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6E5C1591-9306-4498-BF41-A536F623ACF7">
      <SHORT-NAME>ActiveEcuC</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="12914BE7-2F61-498A-8F5A-B490F69188CE">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9C3171D8-F66C-4FBB-89D1-9865247C1644">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="56692ED6-36DA-4BA3-89A1-C6F436E0547B">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2953E451-EE0E-447A-949C-EEFB49E2311A">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EB808A5B-1C9F-44A6-971E-615D002E3F1A">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="593059B5-EAA1-48FA-8AC9-DDC8AE527B17">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CECDF73C-D3EE-4242-90CE-AD919ABA774C">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>