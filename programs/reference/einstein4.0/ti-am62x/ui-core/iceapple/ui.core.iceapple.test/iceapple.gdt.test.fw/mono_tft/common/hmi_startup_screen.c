/*============================================================================
 **
 **                     CONFIDENTIAL VISTEON CORPORATION
 **
 ** This is an unpublished work of authorship, which contains trade secrets,
 ** created in 2012. Visteon Corporation owns all rights to this work and
 ** intends to maintain it in confidence to preserve its trade secret status.
 ** Visteon Corporation reserves the right, under the copyright laws of the
 ** United States or those of any other country that may have jurisdiction,
 ** to protect this work as an unpublished work, in the event of an
 ** inadvertent or deliberate unauthorized publication. Visteon Corporation
 ** also reserves its rights under all copyright laws to protect this work as
 ** a published work, when appropriate. Those having access to this work may
 ** not copy it, use it, modify it or disclose the information contained in
 ** it without the written authorization of Visteon Corporation.
 **
 **============================================================================
 **
 ** Name:          hmi_startup_screen.c
 **
 ** Description:   Implements the screen logic and presentation for opening 
 **                screen 
 **
 ** Organization:  GUI Software Section
 **
 **============================================================================
 **
 **==========================================================================*/
#define HMI_STARTUP_SCREEN_C

/*============================================================================
 ** I N C L U D E   F I L E S
 **==========================================================================*/
#include "hmi_logic_state_handler.h"
#include "hmi_gfx_mgr02_layout.h"
#include "hmi_popup_core_if.h"
#include "hmi_msgDefinition.h"
#include "hmi_menu_def_1.inc"
#include "hmi_menu_core_01_logic.h"

#ifdef  __cplusplus
extern "C" {
#endif
/*============================================================================
 ** I N T E R N A L   M A C R O   A N D   T Y P E   D E F I N I T I O N S
 **==========================================================================*/

/*============================================================================
 ** I N T E R N A L   F U N C T I O N   P R O T O T Y P E S
 **==========================================================================*/

/*============================================================================
 ** M E M O R Y   A L L O C A T I O N
 **==========================================================================*/
UINT8 WarningStatus[MSG_NUM_MESSAGES];

/*============================================================================
 ** E N T R Y   P O I N T S  /  D A T A   A C C E S S   S E R V I C E S
 **==========================================================================*/

/****************************************************************************
Function Name        : scr_startup_event
Description          : Event handler
Invocation           : invoked by view manager
Return Value         : None
Critical Section     : None
Parameters           : None
******************************************************************************/
UINT8 scr_startup_event(LSH_EVENT_HANDLER_STATUS_T *p_event_hndl_status_SP){
   if(LSH_IS_ANIM(p_event_hndl_status_SP->button_command)){
      /*
      ** Button event is received during an animation for this screen 
      */
      printf("Animation in progress, ignored request\n");
   }
   else
   {
      UINT8 warningid;
	  //hmi_lsh_add_state(GFX_NEW_SCREENS_1, ANIM_MAX_ID);

      if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_INFO_POPUP, BTN_EV_PRESS))
      {
        hmi_gfx_mgr02_layout_set_text(GFX_TXT_INFO_POPUP_0_1, L"Fine");  

				hmi_popup_core_activate_popup(L1_INFO_POPUP_ID, ANIM_MAX_ID);
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_ACK_POPUP, BTN_EV_PRESS))
      {
          //hmi_popup_core_activate_popup(L1_INFO_POPUP_ID, ANIM_MAX_ID);
		  hmi_popup_core_activate_popup(L1_ACK_POPUP_ID, ANIM_MAX_ID);

      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_PROGRESS_POPUP, BTN_EV_PRESS))
      {
          hmi_popup_core_activate_popup(L1_PROGRESS_POPUP_ID, ANIM_MAX_ID);
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_KEYPAD_POPUP, BTN_EV_PRESS))
      {
          hmi_popup_core_activate_popup(L1_KEYPAD_POPUP_ID, ANIM_MAX_ID);
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_HARD_WRNG, BTN_EV_PRESS))
      {
          WarningStatus[HARD_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_DEACTIVATE_WRNG, BTN_EV_PRESS))
      {
          for(warningid = 0; warningid < MSG_NUM_MESSAGES; warningid++)
          {
              WarningStatus[warningid] = MSG_CONDITION_OFF;
          }
      }	
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_SOFT_WRNG, BTN_EV_PRESS))
      {
        WarningStatus[SOFT_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_INFO_WRNG, BTN_EV_PRESS))
      {
          WarningStatus[INFO_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_MENU, BTN_EV_PRESS))
      {
          hmi_menu_initialize();
          hmi_menu_logic_Menu_Open(ROOT_MENU_ID, ANIM_MAX_ID);
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_ESC, BTN_EV_PRESS))
      {
          hmi_menu_logic_Close_all_Menu();
      }
      else
      {
      }
   }
   /*
   ** Possible return values for a button event handler
   ** LSH_STATUS_ABSORBED - indicates that the button is absorbed by the button 
   **                       processing function and no further actions need to be performed.
   ** LSH_STATUS_ACTION   - indicates that the button event handler has performed 
   **                       some actions for the event.
   ** LSH_STATUS_NONE     - Button is not absorbed and no action also taken.
   ** Combinations are also possible
   ** (LSH_STATUS_ABSORBED|LSH_STATUS_ACTION) or (LSH_STATUS_NONE|LSH_STATUS_ACTION)
   */
   return(LSH_STATUS_ABSORBED);
}

/****************************************************************************
Function Name        : scr_startup_focus
Description          : Focus handler
Invocation           : invoked by view manager
Return Value         : None
Critical Section     : None
Parameters           : None
******************************************************************************/
void scr_startup_focus(LSH_FOCUS_HANDLER_STATUS_T * p_focus_hndl_status_SP){

   if(p_focus_hndl_status_SP->focus_status & LSH_GOT_FOCUS_STATUS){
	  printf("Got Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if(p_focus_hndl_status_SP->focus_status & LSH_LOST_FOCUS_STATUS){
	  printf("Lost Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if(p_focus_hndl_status_SP->focus_status & LSH_DEACTIVATED_STATUS){
	  printf("Deactivated Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if((p_focus_hndl_status_SP->focus_status & LSH_DEACT_PENDING_STATUS) == LSH_DEACT_PENDING_STATUS){
	  printf("Deactivation pending Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if(p_focus_hndl_status_SP->focus_status & LSH_ANIM_STARTED_STATUS){
	  printf("Anim started Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if(p_focus_hndl_status_SP->focus_status & LSH_ANIM_COMPLETE_STATUS){
	  printf("Anim complete Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
}

/****************************************************************************
Function Name        : scr_startup_pres
Description          : Presentation handler
Invocation           : invoked by view manager
Return Value         : None
Critical Section     : None
Parameters           : None
******************************************************************************/
void scr_startup_pres(LSH_PRESN_HANDLER_STATUS_T *p_presen_hndl_status_SP){


	if(p_presen_hndl_status_SP->presentation_status == LSH_ACTIVATED_STATUS){
				hmi_gfx_mgr02_layout_set_screen(p_presen_hndl_status_SP->logic_state_id, 1);
	}
	else if(p_presen_hndl_status_SP->presentation_status == LSH_REFRESH_STATUS){
	}
	else{ /* LSH_DEACTIVATED_STATUS */
	   hmi_gfx_mgr02_layout_set_screen(p_presen_hndl_status_SP->logic_state_id, 0);
	}
}

/*============================================================================
 **
 **============================================================================
 ** C M S    R E V I S I O N    N O T E S
 **============================================================================
 **
 ** For each change to this file, be sure to record:
 ** 1.  Who made the change and when the change was made.
 ** 2.  Why the change was made and the intended result.
 **
 ** CMS Rev #        Date         By
 ** CMS Rev X.X      mm/dd/yy     CDSID
 **
 **============================================================================
 **
 ** CMS Rev 1.0      09-Mar-2015    EMANOJ1
 ** Creation.
 **==========================================================================*/
#ifdef  __cplusplus
}
#endif
