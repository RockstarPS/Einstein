/*============================================================================
 **
 **                     CONFIDENTIAL VISTEON CORPORATION
 **
 ** This is an unpublished work of authorship, which contains trade secrets,
 ** created in 2012. Visteon Corporation owns all rights to this work and
 ** intends to maintain it in confidence to preserve its trade secret status.
 ** Visteon Corporation reserves the right, under the copyright laws of the
 ** United States or those of any other country that may have jurisdiction,
 ** to protect this work as an unpublished work, in the event of an
 ** inadvertent or deliberate unauthorized publication. Visteon Corporation
 ** also reserves its rights under all copyright laws to protect this work as
 ** a published work, when appropriate. Those having access to this work may
 ** not copy it, use it, modify it or disclose the information contained in
 ** it without the written authorization of Visteon Corporation.
 **
 **============================================================================
 **
 ** Name:          hmi_startup_screen.c
 **
 ** Description:   Implements the screen logic and presentation for opening 
 **                screen 
 **
 ** Organization:  GUI Software Section
 **
 **============================================================================
 **
 **==========================================================================*/
#define HMI_STARTUP_SCREEN_C

/*============================================================================
 ** I N C L U D E   F I L E S
 **==========================================================================*/
#include "hmi_logic_state_handler.h"
#include "hmi_gfx_mgr02_if.h"
#include "hmi_popup_core_if.h"
#include "hmi_msgDefinition.h"
#include "hmi_menu_def_1.inc"
#include "hmi_menu_core_01_logic.h"

#ifdef  __cplusplus
extern "C" {
#endif
/*============================================================================
 ** I N T E R N A L   M A C R O   A N D   T Y P E   D E F I N I T I O N S
 **==========================================================================*/

/*============================================================================
 ** I N T E R N A L   F U N C T I O N   P R O T O T Y P E S
 **==========================================================================*/

/*============================================================================
 ** M E M O R Y   A L L O C A T I O N
 **==========================================================================*/
UINT8 WarningStatus[MSG_NUM_MESSAGES];

/*============================================================================
 ** E N T R Y   P O I N T S  /  D A T A   A C C E S S   S E R V I C E S
 **==========================================================================*/

/****************************************************************************
Function Name        : scr_startup_event
Description          : Event handler
Invocation           : invoked by view manager
Return Value         : None
Critical Section     : None
Parameters           : None
******************************************************************************/
UINT8 scr_startup_event(LSH_EVENT_HANDLER_STATUS_T *p_event_hndl_status_SP){
	
	MSG_VIEWINFO_T temp;
   if(LSH_IS_ANIM(p_event_hndl_status_SP->button_command)){
      /*
      ** Button event is received during an animation for this screen 
      */
      printf("Animation in progress, ignored request\n");
   }
   else
   {
      UINT8 warningid;

      if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_INFO_POPUP, BTN_EV_PRESS))
      {
        hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP_0_1, L"Fine");  
        hmi_popup_core_activate_popup(L1_INFO_POPUP_ID, ANIM_MAX_ID);
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_ACK_POPUP, BTN_EV_PRESS))
      {
          //hmi_popup_core_activate_popup(L1_INFO_POPUP_ID, ANIM_MAX_ID);
		  hmi_popup_core_activate_popup(L1_ACK_POPUP_ID, ANIM_MAX_ID);

      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_PROGRESS_POPUP, BTN_EV_PRESS))
      {
          hmi_popup_core_activate_popup(L1_PROGRESS_POPUP_ID, ANIM_MAX_ID);
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_KEYPAD_POPUP, BTN_EV_PRESS))
      {
          hmi_popup_core_activate_popup(L1_KEYPAD_POPUP_ID, ANIM_MAX_ID);
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_HARD_WRNG, BTN_EV_PRESS))
      {
          WarningStatus[HARD_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_DEACTIVATE_WRNG, BTN_EV_PRESS))
      {
          /*for(warningid = 0; warningid < MSG_NUM_MESSAGES; warningid++)
          {
              WarningStatus[warningid] = MSG_CONDITION_OFF;
          } */ 
		   WarningStatus[HARD_WARNING_ID_INDEX] = MSG_CONDITION_OFF;
		   WarningStatus[SOFT_WARNING_ID_INDEX] = MSG_CONDITION_OFF;
		   WarningStatus[INFO_WARNING_ID_INDEX] = MSG_CONDITION_OFF;
		   WarningStatus[WARN1_WARNING_ID_INDEX] = MSG_CONDITION_OFF;
		   WarningStatus[WARN2_WARNING_ID_INDEX] = MSG_CONDITION_OFF;
		   WarningStatus[WARN3_WARNING_ID_INDEX] = MSG_CONDITION_OFF;
      }	
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_SOFT_WRNG, BTN_EV_PRESS))
      {
		  
		  WarningStatus[SOFT_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
	    //   WarningStatus[INFO_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
	   // WarningStatus[WARN1_WARNING_ID_INDEX] = MSG_CONDITION_RETRIGGER;
      //		WarningStatus[WARN2_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
	 //	WarningStatus[WARN3_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;

		
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_INFO_WRNG, BTN_EV_PRESS))
      {
        
        //WarningStatus[SOFT_WARNING_ID_INDEX] = MSG_CONDITION_FORCED;
     	//	WarningStatus[HARD_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
	    //WarningStatus[WARN1_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
         WarningStatus[INFO_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
		  
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_MENU, BTN_EV_PRESS))
      {
          hmi_menu_initialize(true);
          hmi_menu_logic_Menu_Open(ROOT_MENU_ID, ANIM_MAX_ID);
      }
      else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_ESC, BTN_EV_PRESS))
      {
          hmi_menu_logic_Close_all_Menu();
		  
      }
	  else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_ENTER, BTN_EV_PRESS))
	  {
		  (void)msg_SequencerAction(BTN_ID_ENTER,0);
          
		  (void)msg_SequencerAction(BTN_ID_ENTER,1);
	  }
	  else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_GENWRNG, BTN_EV_PRESS))
      {		  
          WarningStatus[WARN1_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
	      //WarningStatus[HARD_WARNING_ID_INDEX] = MSG_CONDITION_OFF;		   
      }
	  else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_GENWRNG2, BTN_EV_PRESS))
      {
           WarningStatus[WARN2_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
      }
	  else if(p_event_hndl_status_SP->button_command == LSH_GET_COMMAND(BTN_ID_GENWRNG3, BTN_EV_PRESS))
      {
          WarningStatus[WARN3_WARNING_ID_INDEX] = MSG_CONDITION_ACTIVE;
      }
      else
      {
      }
   }
   /*
   ** Possible return values for a button event handler
   ** LSH_STATUS_ABSORBED - indicates that the button is absorbed by the button 
   **                       processing function and no further actions need to be performed.
   ** LSH_STATUS_ACTION   - indicates that the button event handler has performed 
   **                       some actions for the event.
   ** LSH_STATUS_NONE     - Button is not absorbed and no action also taken.
   ** Combinations are also possible
   ** (LSH_STATUS_ABSORBED|LSH_STATUS_ACTION) or (LSH_STATUS_NONE|LSH_STATUS_ACTION)
   */
   return(LSH_STATUS_ABSORBED);
}

/****************************************************************************
Function Name        : scr_startup_focus
Description          : Focus handler
Invocation           : invoked by view manager
Return Value         : None
Critical Section     : None
Parameters           : None
******************************************************************************/
void scr_startup_focus(LSH_FOCUS_HANDLER_STATUS_T * p_focus_hndl_status_SP){

   if(p_focus_hndl_status_SP->focus_status & LSH_GOT_FOCUS_STATUS){
	  printf("Got Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if(p_focus_hndl_status_SP->focus_status & LSH_LOST_FOCUS_STATUS){
	  printf("Lost Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if(p_focus_hndl_status_SP->focus_status & LSH_DEACTIVATED_STATUS){
	  printf("Deactivated Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if((p_focus_hndl_status_SP->focus_status & LSH_DEACT_PENDING_STATUS) == LSH_DEACT_PENDING_STATUS){
	  printf("Deactivation pending Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if(p_focus_hndl_status_SP->focus_status & LSH_ANIM_STARTED_STATUS){
	  printf("Anim started Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
   if(p_focus_hndl_status_SP->focus_status & LSH_ANIM_COMPLETE_STATUS){
	  printf("Anim complete Focus Status : %d\n", p_focus_hndl_status_SP->logic_state_id);
   }
}

/****************************************************************************
Function Name        : scr_startup_pres
Description          : Presentation handler
Invocation           : invoked by view manager
Return Value         : None
Critical Section     : None
Parameters           : None
******************************************************************************/
void scr_startup_pres(LSH_PRESN_HANDLER_STATUS_T *p_presen_hndl_status_SP){
	if(p_presen_hndl_status_SP->presentation_status == LSH_ACTIVATED_STATUS){
	  		// HMI_CHAR buff[5] = {'D','i',92, 'a','\0'}; 
		GFX_MGR02_MULTI_LINE_INFO p;
		HMI_CHAR fl_string_lat[] = L"51.9895\0";
		HMI_CHAR fl_string_lon[] = L"0.9913\0";
		HMI_CHAR fl_buff_GFX[50];
		HMI_CHAR fl_language_sid_P[] = {0x9E, 0x43, 0x6F, 0x6E, 0x6E, 0x65, 0x63, 0x74, 0x65, 0x64, 0x2E, 0x0A, 0x4C, 0x61, 0x74, 0x69, 0x74, 0x75, 0x64, 0x65, 0x3A, 0x20, 0x25, 0x73, 0x0A, 0x4C, 0x6F, 0x6E, 0x67, 0x69, 0x74, 0x07, 0x75, 0x64, 0x65, 0x3A, 0x20, 0x25, 0x73, 0x00};
		hmi_gfx_mgr02_if_set_screen(p_presen_hndl_status_SP->logic_state_id, 1);
		//(void)hmi_gfx_mgr02_if_select_gfont_index(GFX_MGR02_FONT_ID_NEW_FONTS_5,1, 0);
		//(void)hmi_gfx_mgr02_if_select_dimage(GFX_NEW_IMAGES_2,255);
		//hmi_gfx_mgr02_if_set_multi_line_sid(GFX_TXT_INFO_POPUP_0_1_0_0,SID_PROGRESS_POPUP, GFX_TXT_INFO_POPUP_0_1_0_ANIM);

		//(void)HMI_SNPRINTF((void *)&fl_buff_GFX,50 ,&fl_language_sid_P,(void*)&fl_string_lat,(void*)&fl_string_lon);
		
		//hmi_gfx_mgr02_if_set_obj_alpha(GFX_TXT_INFO_POPUP_0_1_0_ANIM, 79);
				//hmi_gfx_mgr02_if_set_obj_alpha(GFX_TXT_INFO_POPUP_0_1_0_0_ANIM, 79);
   // hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"No phone found.\nUnable to place.\nemergency call.\nSo wait", GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);  
//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"iiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiii", GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);  
//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0, L"iiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiii", GFX_TXT_INFO_POPUP_0_1_0_ANIM);  
 
		

		//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"‫يَجْرِي الآن ألإتّصالُ بـ My Thumb Drive the first and last‎", GFX_TXT_INFO_POPUP_0_1_0_0_ANIM); //GFX_TXT_INFO_POPUP_0_1_0_ANIM
        // hmi_gfx_mgr02_layout_set_text(GFX_TXT_INFO_POPUP, L"1"); 
		//hmi_gfx_mgr02_if_set_obj_alpha(GFX_TXT_INFO_POPUP_ANIM, 79);


		
		 //hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"الهاتف غير متراصف أو تمّ رصد غرضالشحن",GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);
//		hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"andnlgfansdgnalnadgnalladglananflsgnasngnal ansowjgt asdfasg",GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);
//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"Part the of indiast abcdefg aodhogha ohsogdho ahdgohoshghngahoe",GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);
		  		//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"Partthereof india abcdefgaodhoghaohsogdhoahdgohoshghngahoe إعدادات السيارة",GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);
				//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"‫يَجْرِي الآن ألإتّصالُ بـ My Thumb Drive the first and last‎",GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);
//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"Display the sensor هذا هو بلدي وأنا أحب أن",GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);
//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"i accept that india bcdefghijklmnoiupqrstuإعدادات السيارة",GFX_TXT_INFO_POPUP_0_1_0_0_ANIM);
		//hmi_gfx_mgr02_get_multiline_info(GFX_TXT_INFO_POPUP_0_1_0_0, &p);
//hmi_gfx_mgr02_layout_set_multi_line_text(GFX_TXT_INFO_POPUP_0_1_0, L"إعدادات السيارة",GFX_TXT_INFO_POPUP_0_1_0_ANIM);

		//hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP_1, L"5311");
		//hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP, L"1MHz");
			//hmi_gfx_mgr02_if_set_obj_pos_y(GFX_NEW_WIDGETS_13_ANIM, 10);

//hmi_gfx_mgr02_if_set_text_prop(GFX_TXT_INFO_POPUP_ANIM,GFX_MGR02_TP_ALIGN_LEFT, GFX_MGR02_TP_DRAW_TRANSP,GFX_MGR02_TP_CLIP_APPEND);
//hmi_gfx_mgr02_if_set_text_prop(GFX_TXT_INFO_POPUP_1_ANIM,GFX_MGR02_TP_ALIGN_LEFT, GFX_MGR02_TP_DRAW_TRANSP,GFX_MGR02_TP_CLIP_APPEND);
		//hmi_gfx_mgr02_if_set_text_prop(GFX_TXT_INFO_POPUP_0_1_0_ANIM,GFX_MGR02_TP_ALIGN_LEFT, GFX_MGR02_TP_DRAW_TRANSP,GFX_MGR02_TP_CLIP_APPEND);
	//hmi_gfx_mgr02_if_set_text_prop(GFX_TXT_INFO_POPUP_0_1_0_0_ANIM,GFX_MGR02_TP_ALIGN_LEFT, GFX_MGR02_TP_DRAW_TRANSP,GFX_MGR02_TP_CLIP_APPEND);
		//hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP_0_1_0_0, L"WWWWWWWWWWWWWWWWWWW");
		//hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP_0_1, "تمّ تنشيط الجرّ على أربع عجلات");

		 //hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP_0_1_0, L"This is my test string for///////multiline character testing of the word warping algorithm that is going to be implemented on the B5151 project");
	//	hmi_gfx_mgr02_if_set_obj_dim_h(GFX_TXT_INFO_POPUP_0_1_0_0_ANIM,3);
		//hmi_gfx_mgr02_layout_select_gfont_index(GFX_MGR02_FONT_ID_NEW_FONTS_5,1,4);
		 		// hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP_0_1, L"DisplaythesensorStatusasper value Mentioned in the indicator Often Shown throughout with accurately values designed in the metre according to rules");
		// hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP_0_1, buff);
		 //hmi_gfx_mgr02_layout_set_text_scroll_parameter(GFX_TXT_INFO_POPUP_0_1_0_ANIM, 1);
//hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP_0_1, L"ipodendwerdasdfd");
//hmi_gfx_mgr02_if_set_obj_pos_x(GFX_NEW_WIDGETS_1_ANIM,100);
//hmi_gfx_mgr02_if_set_text(GFX_TXT_INFO_POPUP, L"WeTheTextDisplayAllInstantAvailableAtTheMomentIncluding");
	}
	else if(p_presen_hndl_status_SP->presentation_status == LSH_REFRESH_STATUS){
	}
	else{ /* LSH_DEACTIVATED_STATUS */
	   hmi_gfx_mgr02_if_set_screen(p_presen_hndl_status_SP->logic_state_id, 0);
	}
}

/*============================================================================
 **
 **============================================================================
 ** C M S    R E V I S I O N    N O T E S
 **============================================================================
 **
 ** For each change to this file, be sure to record:
 ** 1.  Who made the change and when the change was made.
 ** 2.  Why the change was made and the intended result.
 **
 ** CMS Rev #        Date         By
 ** CMS Rev X.X      mm/dd/yy     CDSID
 **
 **============================================================================
 **
 ** CMS Rev 1.0      09-Mar-2015    EMANOJ1
 ** Creation.
 **==========================================================================*/
#ifdef  __cplusplus
}
#endif
